# Keil uVision project project.uvprojx, settings and files
target debug_flash (6160000::V6.16::ARMCLANG)
  device: MIMXRT1062DVL6A NXP
  pack: NXP.MIMXRT1062_DFP.15.0.0
  cpu: IRAM(0x20000000,0x020000) IRAM2(0x00000000,0x020000) XRAM(0x20200000,0x0c0000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: rtthread
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: __STDC_LIMIT_MACROS, __FPU_PRESENT, __RTTHREAD__, SKIP_SYSCLK_INIT, HARD_FP, ARM_MATH_CM7, RT_USING_LIBC, __CLK_TCK=RT_TICK_PER_SECOND, ENDIANNESS, STD=C99, FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1, XIP_BOOT_HEADER_ENABLE=1, FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL, CPU_MIMXRT1062DVL6A, XIP_EXTERNAL_FLASH=1, EVK_MCIMXRM, __SCB_DCACHE_LINE_SIZE=32, RT_USING_ARM_LIBC
  c misc: -xc -std=gnu99 -mimplicit-float -Wno-implicit-function-declaration -Wno-incompatible-function-pointer-types -Wno-absolute-value
  c include: applications;..\..\..\components\libc\compilers\common\include;..\..\..\components\libc\compilers\common\extension;..\..\..\components\libc\compilers\common\extension\fcntl\octal;..\..\..\libcpu\arm\common;..\..\..\libcpu\arm\cortex-m7;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\spi;..\..\..\components\drivers\include;..\..\..\components\drivers\touch;..\..\..\components\drivers\include;..\..\..\components\drivers\include;board;board\MCUX_Config;board\ports;..\libraries\drivers;..\libraries\drivers\config;..\libraries\drivers\wlan\esp8266;..\..\..\components\dfs\include;..\..\..\components\dfs\filesystems\devfs;..\..\..\components\dfs\filesystems\elmfat;..\..\..\components\dfs\filesystems\ramfs;..\..\..\components\finsh;.;..\..\..\include;..\libraries\lcd;..\..\..\components\legacy;..\..\..\components\legacy\dfs;..\libraries\MIMXRT1062\CMSIS\Include;..\libraries\MIMXRT1062\MIMXRT1062;..\libraries\MIMXRT1062\MIMXRT1062\drivers;..\components\openmv_port\lv_binding_micropython;..\components\openmv_port\lv_binding_micropython\lvgl;..\components\openmv_port\lv_binding_micropython\lvgl\src;..\components\openmv_port\lv_binding_micropython\lvgl\src\lv_core;..\components\openmv_port\lv_binding_micropython\lvgl\src\lv_draw;..\components\openmv_port\lv_binding_micropython\lvgl\src\lv_font;..\components\openmv_port\lv_binding_micropython\lvgl\src\lv_gpu;..\components\openmv_port\lv_binding_micropython\lvgl\src\lv_hal;..\components\openmv_port\lv_binding_micropython\lvgl\src\lv_misc;..\components\openmv_port\lv_binding_micropython\lvgl\src\lv_thems;..\components\openmv_port\lv_binding_micropython\lvgl\src\lv_widgets;..\components\openmv_port\lv_binding_micropython\driver\nxp;..\components\openmv_port\lv_binding_micropython\driver\png\lodepng;..\components\openmv_port;..\components\openmv_port\mimxrt_port;..\components\openmv_port\mimxrt_port\modules;..\components\openmv_port\mimxrt_port\modules\machine;..\components\openmv_port\nxp_lib;..\components\openmv_port\nxp_lib\fake_libc_include;..\components\openmv\src\micropython;..\components\openmv\src\micropython\py;..\components\openmv\src\micropython\extmod;..\components\openmv_port\omv_port;..\components\openmv_port\nxp_lib\aia_tf;..\components\openmv\src\omv\alloc;..\components\openmv\src\omv\common;..\components\openmv\src\omv\imlib;..\components\openmv\src\omv\modules;..\components\openmv\src\omv\modules\ulab\code;..\components\openmv\src\omv\modules\ulab\code\scipy\linalg;..\components\openmv\src\omv\modules\ulab\code\scipy\optimize;..\components\openmv\src\omv\modules\ulab\code\scipy\special;..\components\openmv\src\omv\modules\ulab\code\numpy\ndarray;..\components\openmv\src\omv\modules\ulab\code\numpy;..\components\openmv\src\omv\modules\ulab\code\numpy\carray;..\components\openmv\src\omv\modules\ulab\code\numpy\io;..\components\openmv\src\omv\modules\ulab\code\numpy\fft;..\components\openmv\src\omv\modules\ulab\code\user;..\components\openmv\src\omv\modules\ulab\code\utils;..\..\..\components\libc\posix\io\poll;..\..\..\components\libc\posix\io\stdio;..\..\..\components\libc\posix\ipc;..\..\..\components\net\netdev\include;..\..\..\components\net\sal\include;..\..\..\components\net\sal\include\socket;..\..\..\components\net\sal\include\dfs_net;..\..\..\components\net\sal\include\socket\sys_socket;..\libraries\sensors;..\libraries\drivers\usb;..\libraries\drivers\usb\config;..\libraries\drivers\usb\app;..\libraries\drivers\usb\include;..\libraries\drivers\usb\phy;..\libraries\drivers\usb\device;..\libraries\drivers\usb\omv;xip
  memory RVCT6: RAM 0x20200000 size 0xc0000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x0 size 0x20000
  scatter file: .\board\linker_scripts\link.sct
  link misc: --keep=*(.boot_hdr.ivt)--keep=*(.boot_hdr.boot_data)--keep=*(.boot_hdr.dcd_data)--keep=*(.boot_hdr.conf) --datacompressor=off
  group Applications
    applications/: main.c
  group Compiler
    ../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../components/libc/compilers/common/: cctype.c cstdio.c cstdlib.c cstring.c ctime.c cwchar.c
  group cpu
    ../../../libcpu/arm/common/: showmem.c div0.c backtrace.c
  group CPU
    ../../../libcpu/arm/cortex-m7/: cpuport.c cpu_cache.c context_rvds.S
  group DeviceDrivers
    ../../../components/drivers/can/: can.c
    ../../../components/drivers/hwtimer/: hwtimer.c
    ../../../components/drivers/i2c/: i2c_core.c i2c_dev.c
    ../../../components/drivers/ipc/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../components/drivers/misc/: adc.c pin.c rt_drv_pwm.c
    ../../../components/drivers/rtc/: rtc.c
    ../../../components/drivers/sdio/: block_dev.c mmc.c mmcsd_core.c sd.c sdio.c
    ../../../components/drivers/serial/: serial.c
    ../../../components/drivers/spi/: qspi_core.c spi_core.c spi_dev.c
    ../../../components/drivers/touch/: touch.c
    ../../../components/drivers/watchdog/: watchdog.c
  group Drivers
    board/MCUX_Config/: clock_config.c pin_mux.c
    board/: board.c pins_imxrtevk106x.c
    ../libraries/drivers/: drv_adc.c drv_can.c drv_gpio.c drv_hwtimer.c drv_i2c.c drv_pwm.c drv_rtc.c drv_sdio.c drv_spi.c drv_uart.c drv_wdt.c
  group Filesystem
    ../../../components/dfs/filesystems/devfs/: devfs.c
    ../../../components/dfs/filesystems/elmfat/: dfs_elm.c ff.c ffunicode.c
    ../../../components/dfs/filesystems/ramfs/: dfs_ramfs.c
    ../../../components/dfs/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
  group Finsh
    ../../../components/finsh/: shell.c msh.c msh_parse.c cmd.c msh_file.c
  group Kernel
    ../../../src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c memheap.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group LCD
    ../libraries/lcd/: fsl_ft5406_rt.c RK043FN02H.c
  group Legacy
    ../../../components/legacy/ipc/: workqueue_legacy.c
  group Libraries
    ../libraries/MIMXRT1062/MIMXRT1062/drivers/: fsl_flexcan.c fsl_wdog.c fsl_trng.c fsl_lpspi.c fsl_adc.c fsl_clock.c fsl_cache.c fsl_rtwdog.c fsl_csi.c fsl_qtmr.c fsl_snvs_lp.c fsl_gpio.c fsl_pwm.c fsl_lpspi_edma.c fsl_common.c fsl_lpuart.c fsl_elcdif.c fsl_dmamux.c fsl_edma.c fsl_gpt.c fsl_lpi2c.c fsl_flexspi.c fsl_usdhc.c fsl_snvs_hp.c
    ../libraries/MIMXRT1062/MIMXRT1062/arm/: startup_MIMXRT1062.s
    ../libraries/MIMXRT1062/MIMXRT1062/: system_MIMXRT1062.c
  group lvgl
    ../components/openmv_port/lv_binding_micropython/lvgl/src/lv_misc/: lv_debug.c lv_log.c lv_ll.c lv_task.c lv_gc.c lv_printf.c lv_txt.c lv_mem.c lv_fs.c lv_color.c lv_math.c lv_templ.c lv_anim.c lv_utils.c lv_async.c lv_area.c lv_txt_ap.c lv_bidi.c
    ../components/openmv_port/lv_binding_micropython/lvgl/src/lv_widgets/: lv_spinner.c lv_objmask.c lv_label.c lv_line.c lv_linemeter.c lv_table.c lv_spinbox.c lv_keyboard.c lv_calendar.c lv_list.c lv_canvas.c lv_slider.c lv_page.c lv_tileview.c lv_switch.c lv_arc.c lv_textarea.c lv_bar.c lv_btnmatrix.c lv_chart.c lv_objx_templ.c lv_cont.c lv_roller.c lv_checkbox.c lv_win.c lv_cpicker.c lv_dropdown.c lv_tabview.c lv_gauge.c lv_btn.c lv_imgbtn.c lv_img.c lv_msgbox.c lv_led.c
    ../components/openmv_port/lv_binding_micropython/gen/: lv_mpy.c
    ../components/openmv_port/lv_binding_micropython/lvgl/src/lv_draw/: lv_draw_triangle.c lv_draw_blend.c lv_draw_arc.c lv_draw_img.c lv_img_cache.c lv_img_buf.c lv_draw_mask.c lv_img_decoder.c lv_draw_line.c lv_draw_rect.c lv_draw_label.c
    ../components/openmv_port/lv_binding_micropython/lvgl/src/lv_font/: lv_font_unscii_16.c lv_font_montserrat_46.c lv_font_montserrat_14.c lv_font_simsun_16_cjk.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_48.c lv_font_montserrat_28.c lv_font_montserrat_42.c lv_font_montserrat_38.c lv_font_montserrat_8.c lv_font_montserrat_28_compressed.c lv_font_montserrat_18.c lv_font_fmt_txt.c lv_font_montserrat_30.c lv_font_loader.c lv_font_montserrat_44.c lv_font_montserrat_12_subpx.c lv_font_montserrat_16.c lv_font_dejavu_16_persian_hebrew.c lv_font_montserrat_20.c lv_font_montserrat_12.c lv_font_montserrat_40.c lv_font_unscii_8.c lv_font_montserrat_10.c lv_font_montserrat_22.c lv_font_montserrat_26.c lv_font.c lv_font_montserrat_36.c lv_font_montserrat_24.c
    ../components/openmv_port/lv_binding_micropython/lvgl/src/lv_core/: lv_obj.c lv_refr.c lv_style.c lv_indev.c lv_disp.c lv_group.c
    ../components/openmv_port/lv_binding_micropython/lvgl/src/lv_gpu/: lv_gpu_nxp_vglite.c lv_gpu_nxp_pxp.c lv_gpu_stm32_dma2d.c lv_gpu_nxp_pxp_osa.c
    ../components/openmv_port/lv_binding_micropython/lvgl/src/lv_themes/: lv_theme_template.c lv_theme_empty.c lv_theme.c lv_theme_material.c lv_theme_mono.c
    ../components/openmv_port/lv_binding_micropython/driver/png/gen/: lodepng.c mp_lodepng.c lodepng.pp.c
    ../components/openmv_port/lv_binding_micropython/driver/nxp/: lv_helper_nxp.c input.c
    ../components/openmv_port/lv_binding_micropython/lvgl/src/lv_hal/: lv_hal_disp.c lv_hal_tick.c lv_hal_indev.c
  group micropython
    ../components/openmv/src/micropython/extmod/: machine_spi.c machine_signal.c modubinascii.c modnetwork.c moductypes.c moduwebsocket.c moducryptolib.c moduhashlib.c moduheapq.c modujson.c vfs_posix_file.c vfs_fat.c moduplatform.c vfs_fat_diskio.c vfs_posix.c vfs_blockdev.c modurandom.c utime_mphal.c vfs.c modure.c vfs_fat_file.c modusocket.c vfs_reader.c mpbthci.c modussl_axtls.c moduselect.c uos_dupterm.c modussl_mbedtls.c moduzlib.c moduasyncio.c machine_mem.c machine_pinbase.c machine_pulse.c virtpin.c machine_i2c.c modwebrepl.c modutimeq.c
    ../components/openmv_port/mimxrt_port/modules/machine/: modmachine.c machine_hw_spi.c machine_adc.c machine_pin.c machine_uart.c machine_lcd.c machine_timer.c machine_hw_i2c.c machine_wdt.c machine_rtc.c machine_pwm.c
    ../components/openmv/src/micropython/py/: modgc.c argcheck.c objgenerator.c unicode.c asmarm.c modarray.c mpstate.c modcollections.c objstringio.c scope.c persistentcode.c moduerrno.c nlrthumb.c objattrtuple.c modbuiltins.c objstrunicode.c repl.c objboundmeth.c asmthumb.c objclosure.c sequence.c parse.c objdict.c frozenmod.c objset.c profile.c objzip.c emitglue.c objfun.c reader.c emitnarm.c bc.c objtuple.c parsenumbase.c builtinimport.c obj.c objmap.c qstr.c runtime.c objenumerate.c builtinevex.c objint_mpz.c showbc.c objcomplex.c objarray.c objint_longlong.c smallint.c pairheap.c objexcept.c emitcommon.c objgetitemiter.c warning.c emitinlinethumb.c objnamedtuple.c stream.c pystack.c binary.c modcmath.c objlist.c nativeglue.c modstruct.c emitnthumb.c objnone.c vm.c emitnative.c malloc.c objmodule.c vstr.c mpz.c modio.c objreversed.c modmicropython.c objobject.c parsenum.c mpprint.c objslice.c stackctrl.c formatfloat.c objfilter.c objbool.c objproperty.c omvdummy.c nlr.c emitbc.c objint.c opmethods.c lexer.c objfloat.c objcell.c objrange.c objtype.c modmath.c objstr.c ringbuf.c builtinhelp.c asmbase.c modsys.c objsingleton.c scheduler.c objdeque.c compile.c objpolyiter.c runtime_utils.c gc.c map.c
    ../components/openmv_port/mimxrt_port/: moduos_vfs.c pendsv.c mphalport.c irqmap.c mpputsnport.c gccollect.c bufhelper.c mpgetcharport.c mpy_main.c modservo.c modrng.c modmimxrt.c modos.c mpy_pin.c mpthreadport.c modled.c
    ../components/openmv_port/nxp_lib/aia_cmm/: cfg_mux_mgr.c
    ../components/openmv_port/mimxrt_port/modules/: moduos.c modrtthread.c modmcu.c modpyb.c modutime.c
    ../components/openmv_port/nxp_lib/aia_doc/: doc_mgr.c
    ../components/openmv/src/micropython/shared/runtime/: pyexec.c mpirq.c interrupt_char.c gchelper_generic.c stdout_helpers.c
    ../components/openmv/src/micropython/drivers/bus/: softspi.c
    ../components/openmv/src/micropython/drivers/dht/: dht.c
    ../components/openmv_port/nxp_lib/fake_libc_include/: fake_libc.c
    ../components/openmv/src/micropython/shared/timeutils/: timeutils.c
    ../components/openmv/src/micropython/shared/readline/: readline.c
  group openmv
    ../components/openmv/src/omv/imlib/: fft.c stats.c pool.c ppm.c qsort.c hog.c haar.c lsd.c selective_search.c hough.c imlib.c sincos_tab.c draw.c template.c mjpeg.c bmp.c xyz_tab.c yuv.c dmtx.c lab_tab.c zbar.c clahe.c apriltag.c mathop.c phasecorrelation.c qrcode.c blob.c eye.c point.c fmath.c integral_mw.c font.c line.c agast.c integral.c fsort.c rainbow_tab.c gif.c png.c jpegd.c collections.c jpeg.c binary.c lbp.c edge.c rectangle.c orb.c filter.c bayer.c
    ../components/openmv/src/hal/cmsis/src/dsp/FastMathFunctions/: arm_sin_q31.c arm_sqrt_q31.c arm_sqrt_q15.c arm_sin_q15.c arm_sin_f32.c arm_cos_q15.c arm_cos_f32.c arm_cos_q31.c
    ../components/openmv/src/hal/cmsis/src/dsp/TransformFunctions/: arm_rfft_init_q15.c arm_rfft_init_q31.c
    ../components/openmv/src/omv/alloc/: umm_malloc.c unaligned_memcpy.c dma_alloc.c xalloc.c fb_alloc.c
    ../components/openmv/src/omv/common/: trace.c array.c ringbuf.c factoryreset.c
    ../components/openmv/src/omv/modules/ulab/code/numpy/linalg/: linalg.c linalg_tools.c
    ../components/openmv/src/omv/modules/ulab/code/numpy/: vector.c numerical.c stats.c compare.c numpy.c filter.c approx.c transform.c poly.c create.c
    ../components/openmv_port/omv_port/: mutex.c omv_main.c framebuffer.c usbdbg.c nxp_module.c py_helper.c py_sensor.c ff_wrapper.c py_tf.c sensor_utils.c
    ../components/openmv/src/omv/modules/ulab/code/numpy/fft/: fft_tools.c fft.c
    ../components/openmv/src/omv/modules/ulab/code/numpy/carray/: carray.c carray_tools.c
    ../components/openmv/src/omv/modules/: py_mjpeg.c py_imageio.c py_gif.c py_image.c py_omv.c py_clock.c examplemodule.c
    ../components/openmv/src/omv/modules/ulab/code/: ulab_tools.c ndarray.c ndarray_operators.c ndarray_properties.c ulab.c
    ../components/openmv/src/omv/modules/ulab/code/numpy/ndarray/: ndarray_iter.c
    ../components/openmv/src/hal/cmsis/src/dsp/CommonTables/: arm_common_tables.c arm_const_structs.c
    ../components/openmv/src/omv/modules/ulab/code/utils/: utils.c
    ../components/openmv/src/omv/modules/ulab/code/user/: user.c
    ../components/openmv_port/nxp_lib/aia_tf/: libtf.lib
  group POSIX
    ../../../components/libc/posix/io/poll/: poll.c select.c
    ../../../components/libc/posix/io/stdio/: libc.c
  group SAL
    ../../../components/net/netdev/src/: netdev.c netdev_ipaddr.c
    ../../../components/net/sal/dfs_net/: dfs_net.c
    ../../../components/net/sal/socket/: net_netdb.c net_sockets.c
    ../../../components/net/sal/src/: sal_socket.c
  group Sensors
    ../libraries/sensors/: mt9m114.c drv_camera_int.c ov7725.c
  group usb
    ../libraries/drivers/usb/app/: composite.c usb_device_cdc_acm.c usb_device_msc_ufi.c virtual_com.c usb_device_ch9.c usb_device_class.c usb_device_descriptor.c ring_buffer.c usbd_msc_storage.c usb_device_msc.c
    ../libraries/drivers/usb/omv/: drv_usb_omv.c
    ../libraries/drivers/usb/phy/: usb_phy.c
    ../libraries/drivers/usb/device/: usb_device_ehci.c usb_device_dci.c
  group xip
    xip/: evkmimxrt1060_flexspi_nor_config.c evkmimxrt1060_sdram_ini_dcd.c fsl_flexspi_nor_boot.c
target debug_sram (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MIMXRT1062DVL6A NXP
  pack: NXP.MIMXRT1062_DFP.15.0.0
  cpu: as above
  output: rtthread
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: as above
  c misc: as above
  c include: as above
  memory RVCT6: RAM 0x20200000 size 0xc0000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x0 size 0x20000
  scatter file: .\board\linker_scripts\sdram.sct
  link misc: as above
