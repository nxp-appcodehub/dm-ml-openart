# Keil uVision project project.uvprojx, settings and files
target debug_flash (6190000::V6.19::ARMCLANG)
  device: MIMXRT1176DVMAA:cm7 NXP
  pack: NXP.MIMXRT1176_DFP.15.0.0
  cpu: IRAM(0x20000000,0x020000) IRAM2(0x20000000,0x040000) IROM(0x00200000,0x040000) XRAM(0x1ffe0000,0x020000) XRAM2(0x00000000,0x040000) XRAM3(0x20240000,0x080000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: rtthread
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: CPU_MIMXRT1176DVMAA_cm7, __STDC_LIMIT_MACROS, ENDIANNESS, SKIP_SYSCLK_INIT, RT_USING_LIBC, XIP_BOOT_HEADER_ENABLE=1,XIP_BOOT_HEADER_DCD_ENABLE=1,ARM_MATH_CM7,__FPU_PRESENT,FFCONF_H="oofatfs/ffconf.h",HARD_FP,FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1, __CLK_TCK=RT_TICK_PER_SECOND, STD=C99, __SCB_DCACHE_LINE_SIZE=32, __RTTHREAD__, SKIP_SEMC_INIT, FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL, EVK_MCIMXRM, XIP_EXTERNAL_FLASH=1, RT_USING_ARM_LIBC
  c misc: -xc -std=gnu99 -mimplicit-float -Wno-implicit-function-declaration -Wno-incompatible-function-pointer-types -Wno-absolute-value
  c include: applications;..\..\..\components\libc\compilers\common\include;..\..\..\components\libc\compilers\common\extension;..\..\..\components\libc\compilers\common\extension\fcntl\octal;..\..\..\libcpu\arm\common;..\..\..\libcpu\arm\cortex-m7;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\spi;..\..\..\components\drivers\include;..\..\..\components\drivers\touch;..\..\..\components\drivers\include;..\..\..\components\drivers\include;board;board\MCUX_Config;board\ports;..\libraries\drivers;..\libraries\drivers\config;..\libraries\drivers\wlan\esp8266;..\..\..\components\dfs\include;..\..\..\components\dfs\filesystems\devfs;..\..\..\components\dfs\filesystems\elmfat;..\..\..\components\dfs\filesystems\ramfs;..\..\..\components\finsh;.;..\..\..\include;..\..\..\components\legacy;..\..\..\components\legacy\dfs;..\libraries\MIMXRT1170\CMSIS\Include;..\libraries\MIMXRT1170\MIMXRT1176;..\libraries\MIMXRT1170\MIMXRT1176\drivers;..\libraries\MIMXRT1170\MIMXRT1176\drivers\cm7;..\components\openmv_port;..\components\openmv_port\mimxrt_port;..\components\openmv_port\mimxrt_port\modules;..\components\openmv_port\mimxrt_port\modules\machine;..\components\openmv_port\nxp_lib;..\components\openmv_port\nxp_lib\fake_libc_include;..\components\openmv\src\micropython;..\components\openmv\src\micropython\py;..\components\openmv\src\micropython\extmod;..\components\openmv_port\omv_port;..\components\openmv_port\nxp_lib\aia_tf;..\components\openmv\src\omv\alloc;..\components\openmv\src\omv\common;..\components\openmv\src\omv\imlib;..\components\openmv\src\omv\modules;..\components\openmv\src\omv\modules\ulab\code;..\components\openmv\src\omv\modules\ulab\code\scipy\linalg;..\components\openmv\src\omv\modules\ulab\code\scipy\optimize;..\components\openmv\src\omv\modules\ulab\code\scipy\special;..\components\openmv\src\omv\modules\ulab\code\numpy\ndarray;..\components\openmv\src\omv\modules\ulab\code\numpy;..\components\openmv\src\omv\modules\ulab\code\numpy\carray;..\components\openmv\src\omv\modules\ulab\code\numpy\io;..\components\openmv\src\omv\modules\ulab\code\numpy\fft;..\components\openmv\src\omv\modules\ulab\code\user;..\components\openmv\src\omv\modules\ulab\code\utils;..\..\..\components\libc\posix\io\poll;..\..\..\components\libc\posix\io\stdio;..\..\..\components\libc\posix\ipc;..\..\..\components\net\netdev\include;..\..\..\components\net\sal\include;..\..\..\components\net\sal\include\socket;..\..\..\components\net\sal\include\dfs_net;..\..\..\components\net\sal\include\socket\sys_socket;..\..\..\components\drivers\sensors;..\..\..\components\drivers\include;..\libraries\sensors;..\libraries\drivers\usb;..\libraries\drivers\usb\config;..\libraries\drivers\usb\app;..\libraries\drivers\usb\include;..\libraries\drivers\usb\phy;..\libraries\drivers\usb\device;..\libraries\drivers\usb\omv;xip
  memory RVCT4: ROM 0x200000 size 0x40000
  memory RVCT6: RAM 0x1ffe0000 size 0x20000
  memory RVCT7: RAM 0x0 size 0x40000
  memory RVCT8: RAM 0x20240000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\board\linker_scripts\link.sct
  link misc: --keep=*(.boot_hdr.ivt)--keep=*(.boot_hdr.boot_data)--keep=*(.boot_hdr.dcd_data)--keep=*(.boot_hdr.conf) --legacyalign
  group Applications
    applications/: main.c
  group Compiler
    ../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../components/libc/compilers/common/: cctype.c cstdio.c cstdlib.c cstring.c ctime.c cwchar.c
  group cpu
    ../../../libcpu/arm/common/: div0.c backtrace.c showmem.c
  group CPU
    ../../../libcpu/arm/cortex-m7/: cpu_cache.c cpuport.c context_rvds.S
  group DeviceDrivers
    ../../../components/drivers/hwtimer/: hwtimer.c
    ../../../components/drivers/i2c/: i2c_core.c i2c_dev.c
    ../../../components/drivers/ipc/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../components/drivers/misc/: adc.c pin.c rt_drv_pwm.c
    ../../../components/drivers/rtc/: rtc.c
    ../../../components/drivers/sdio/: block_dev.c mmc.c mmcsd_core.c sd.c sdio.c
    ../../../components/drivers/serial/: serial.c
    ../../../components/drivers/spi/: qspi_core.c spi_core.c spi_dev.c
    ../../../components/drivers/touch/: touch.c
    ../../../components/drivers/watchdog/: watchdog.c
  group Drivers
    board/MCUX_Config/: clock_config.c pin_mux.c
    board/: board.c pins_imxrtevk117x.c
    ../libraries/drivers/: drv_gpio.c drv_hwtimer.c drv_i2c.c drv_pwm.c drv_rtc.c drv_sdio.c drv_spi.c drv_uart.c drv_wdt.c
  group Filesystem
    ../../../components/dfs/filesystems/devfs/: devfs.c
    ../../../components/dfs/filesystems/elmfat/: dfs_elm.c ff.c ffunicode.c
    ../../../components/dfs/filesystems/ramfs/: dfs_ramfs.c
    ../../../components/dfs/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
  group Finsh
    ../../../components/finsh/: shell.c msh.c msh_parse.c cmd.c msh_file.c
  group Kernel
    ../../../src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c memheap.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group Legacy
    ../../../components/legacy/ipc/: workqueue_legacy.c
  group Libraries
    ../libraries/MIMXRT1170/MIMXRT1176/drivers/: fsl_anatop.c fsl_gpt.c fsl_lpspi.c fsl_snvs_lp.c fsl_anatop_ai.c fsl_mipi_csi2rx.c fsl_soc_mipi_csi2rx.c fsl_lpuart.c fsl_wdog.c fsl_clock.c fsl_pmu.c fsl_caam.c fsl_gpio.c fsl_rtwdog.c fsl_qtmr.c fsl_edma.c fsl_common.c fsl_lpspi_edma.c fsl_lpi2c.c fsl_pwm.c fsl_csi.c fsl_usdhc.c fsl_snvs_hp.c
    ../libraries/MIMXRT1170/MIMXRT1176/drivers/cm7/: fsl_cache.c
    ../libraries/MIMXRT1170/MIMXRT1176/arm/: startup_MIMXRT1176_cm7.S
    ../libraries/MIMXRT1170/MIMXRT1176/: system_MIMXRT1176_cm7.c
  group micropython
    ../components/openmv/src/micropython/py/: objexcept.c asmthumb.c map.c objattrtuple.c objint.c objcell.c compile.c emitbc.c parsenumbase.c parse.c modgc.c objnone.c objstrunicode.c objrange.c asmarm.c emitcommon.c objfun.c objint_mpz.c modmath.c qstr.c objgetitemiter.c runtime_utils.c emitglue.c objnamedtuple.c objbool.c nativeglue.c warning.c modsys.c sequence.c objarray.c showbc.c modstruct.c objtype.c parsenum.c gc.c objdeque.c objboundmeth.c smallint.c argcheck.c frozenmod.c objpolyiter.c persistentcode.c modmicropython.c objtuple.c objmap.c stackctrl.c emitinlinethumb.c malloc.c objproperty.c objenumerate.c mpprint.c omvdummy.c objmodule.c stream.c emitnarm.c nlr.c objstringio.c pystack.c modio.c profile.c objobject.c unicode.c nlrthumb.c objlist.c objzip.c mpstate.c repl.c objgenerator.c vm.c builtinevex.c formatfloat.c objset.c reader.c moduerrno.c objfloat.c objint_longlong.c vstr.c emitnative.c emitnthumb.c objsingleton.c obj.c bc.c lexer.c scope.c objstr.c modarray.c objcomplex.c ringbuf.c binary.c mpz.c scheduler.c opmethods.c modbuiltins.c objdict.c runtime.c modcollections.c objreversed.c pairheap.c asmbase.c modcmath.c objfilter.c objclosure.c builtinhelp.c builtinimport.c objslice.c
    ../components/openmv/src/micropython/extmod/: uos_dupterm.c utime_mphal.c machine_pulse.c modussl_axtls.c vfs_fat_file.c modubinascii.c modnetwork.c moduheapq.c moduzlib.c moduhashlib.c machine_i2c.c vfs_reader.c modure.c machine_pinbase.c vfs_posix_file.c moduplatform.c modwebrepl.c virtpin.c vfs.c machine_signal.c moduasyncio.c modusocket.c vfs_blockdev.c machine_mem.c moducryptolib.c vfs_fat.c moductypes.c modussl_mbedtls.c machine_spi.c moduwebsocket.c modurandom.c moduselect.c modutimeq.c vfs_posix.c mpbthci.c vfs_fat_diskio.c modujson.c
    ../components/openmv/src/micropython/shared/readline/: readline.c
    ../components/openmv_port/mimxrt_port/modules/machine/: machine_timer.c machine_lcd.c machine_pin.c machine_wdt.c modmachine.c machine_adc.c machine_uart.c machine_hw_spi.c machine_pwm.c machine_hw_i2c.c machine_rtc.c
    ../components/openmv/src/micropython/drivers/bus/: softspi.c
    ../components/openmv/src/micropython/shared/timeutils/: timeutils.c
    ../components/openmv_port/mimxrt_port/: modled.c mpy_main.c bufhelper.c moduos_vfs.c gccollect.c mpy_pin.c modmimxrt.c modrng.c mpgetcharport.c mphalport.c mpputsnport.c mpthreadport.c modservo.c pendsv.c modos.c irqmap.c
    ../components/openmv/src/micropython/shared/runtime/: pyexec.c stdout_helpers.c gchelper_generic.c mpirq.c interrupt_char.c
    ../components/openmv_port/mimxrt_port/modules/: modrtthread.c modmcu.c modutime.c moduos.c modpyb.c
    ../components/openmv/src/micropython/drivers/dht/: dht.c
    ../components/openmv_port/nxp_lib/aia_doc/: doc_mgr.c
    ../components/openmv_port/nxp_lib/aia_cmm/: cfg_mux_mgr.c
    ../components/openmv_port/nxp_lib/fake_libc_include/: fake_libc.c
  group openmv
    ../components/openmv/src/omv/imlib/: bayer.c agast.c clahe.c integral.c binary.c pool.c integral_mw.c blob.c png.c mjpeg.c bmp.c phasecorrelation.c font.c lab_tab.c collections.c dmtx.c xyz_tab.c rectangle.c lsd.c draw.c haar.c line.c edge.c fsort.c lodepng.c rainbow_tab.c mathop.c gif.c template.c sincos_tab.c fmath.c apriltag.c selective_search.c ppm.c qsort.c point.c qrcode.c stats.c eye.c jpegd.c orb.c hog.c yuv.c fft.c jpeg.c hough.c imlib.c lbp.c zbar.c filter.c
    ../components/openmv/src/omv/modules/ulab/code/numpy/carray/: carray.c carray_tools.c
    ../components/openmv/src/omv/modules/: py_gif.c examplemodule.c py_clock.c py_image.c py_omv.c py_imageio.c py_mjpeg.c
    ../components/openmv_port/omv_port/: sensor_utils.c nxp_module.c usbdbg.c omv_main.c py_sensor.c ff_wrapper.c py_tf.c framebuffer.c mutex.c py_helper.c
    ../components/openmv/src/omv/modules/ulab/code/numpy/: transform.c compare.c numpy.c vector.c numerical.c create.c approx.c filter.c poly.c stats.c
    ../components/openmv/src/omv/modules/ulab/code/numpy/linalg/: linalg.c linalg_tools.c
    ../components/openmv/src/hal/cmsis/src/dsp/TransformFunctions/: arm_rfft_init_q31.c arm_rfft_init_q15.c
    ../components/openmv/src/omv/alloc/: fb_alloc.c dma_alloc.c umm_malloc.c xalloc.c unaligned_memcpy.c
    ../components/openmv/src/omv/modules/ulab/code/: ulab.c ndarray_properties.c ndarray_operators.c ulab_tools.c ndarray.c
    ../components/openmv/src/hal/cmsis/src/dsp/FastMathFunctions/: arm_cos_q31.c arm_sqrt_q15.c arm_sin_q31.c arm_sqrt_q31.c arm_sin_q15.c arm_sin_f32.c arm_cos_q15.c arm_cos_f32.c
    ../components/openmv/src/hal/cmsis/src/dsp/CommonTables/: arm_common_tables.c arm_const_structs.c
    ../components/openmv/src/omv/common/: ringbuf.c factoryreset.c array.c trace.c
    ../components/openmv/src/omv/modules/ulab/code/numpy/fft/: fft.c fft_tools.c
    ../components/openmv/src/omv/modules/ulab/code/numpy/io/: io.c
    ../components/openmv/src/omv/modules/ulab/code/user/: user.c
    ../components/openmv/src/omv/modules/ulab/code/numpy/ndarray/: ndarray_iter.c
    ../components/openmv/src/omv/modules/ulab/code/utils/: utils.c
    ../components/openmv_port/nxp_lib/aia_tf/: libtf.lib
  group POSIX
    ../../../components/libc/posix/io/poll/: poll.c select.c
    ../../../components/libc/posix/io/stdio/: libc.c
  group SAL
    ../../../components/net/netdev/src/: netdev.c netdev_ipaddr.c
    ../../../components/net/sal/dfs_net/: dfs_net.c
    ../../../components/net/sal/socket/: net_netdb.c net_sockets.c
    ../../../components/net/sal/src/: sal_socket.c
  group Sensors
    ../../../components/drivers/sensors/: sensor.c sensor_cmd.c
    ../libraries/sensors/: drv_camera_mipi.c ov5640.c
  group usb
    ../libraries/drivers/usb/device/: usb_device_ehci.c usb_device_dci.c
    ../libraries/drivers/usb/app/: composite.c usbd_msc_storage.c usb_device_msc.c usb_device_descriptor.c usb_device_ch9.c ring_buffer.c virtual_com.c usb_device_msc_ufi.c usb_device_cdc_acm.c usb_device_class.c
    ../libraries/drivers/usb/omv/: drv_usb_omv.c
    ../libraries/drivers/usb/phy/: usb_phy.c
  group xip
    xip/: evkmimxrt1170_sdram_ini_dcd.c fsl_flexspi_nor_boot.c evkmimxrt1170_flexspi_nor_config.c
target debug_sram (6220000::V6.22::ARMCLANG)
  device: MIMXRT1176DVMAA:cm7 NXP
  pack: NXP.MIMXRT1176_DFP.15.0.0
  cpu: as above
  output: rtthread
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: as above
  c misc: as above
  c include: as above
  memory RVCT4: ROM 0x200000 size 0x40000
  memory RVCT6: RAM 0x1ffe0000 size 0x20000
  memory RVCT7: RAM 0x0 size 0x40000
  memory RVCT8: RAM 0x20240000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\board\linker_scripts\sdram.sct
  link misc: as above
